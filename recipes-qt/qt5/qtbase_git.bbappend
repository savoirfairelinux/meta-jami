PACKAGECONFIG_append = " dbus sql-sqlite gif"
