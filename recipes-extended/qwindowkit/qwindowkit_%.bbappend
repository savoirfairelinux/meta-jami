EXTRA_OECMAKE = " \
    -DQWINDOWKIT_BUILD_WIDGETS=OFF \
    -DQWINDOWKIT_BUILD_STATIC=ON \
    -DQWINDOWKIT_BUILD_QUICK=ON \
"
