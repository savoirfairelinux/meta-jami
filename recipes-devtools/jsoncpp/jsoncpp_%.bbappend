FILESEXTRAPATHS_prepend := "${THISDIR}/jsoncpp:"
SRC_URI += "file://0001-Fixed-pkg-config-Version.patch"
